# Keil uVision project LedArray.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: LedArray +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include
  group START
    ./: STARTUP.A51
  group USER
    ./USER/: main.c bsp_sensor.c display.c
  group Common
    ./Common/: Common.c Delay.c
